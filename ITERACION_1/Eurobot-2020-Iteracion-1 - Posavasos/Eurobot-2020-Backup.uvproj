# Keil uVision project Eurobot-2020-Backup.uvproj, settings and files
target Simulator (ARM-ADS)
  device: LPC1768 NXP
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Eurobot-2020-Backup
  c flags: Optim=1
  c include: ..\Eurobot-2020-Backup-2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup
    ./: startup_LPC17xx.s system_LPC17xx.c
  group Source
    ./: main.c
  group Libraries
    ./: Eurouart.c GLCD.c AsciiLib.c funciones_control.c funciones_timer.c configuraciones.c funciones_pwm.c funciones_desplazamiento.c
target Hardware (ARM-ADS)
  device: LPC1768 NXP
  cpu: as above
  output: Eurobot-2020-Backup
  c flags: Optim=1
  c include: ..\Eurobot-2020-Backup-2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
